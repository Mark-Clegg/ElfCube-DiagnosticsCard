# Repository Mark-Clegg/ElfCube-DiagnosticsCard

File README.md:

# Elf-Cube - Diagnostics Card
Simple retro computer based on the 1802 series of processors.

- Diagnostics Card
Provides visual indication of I/O operations, latching the current state of the N lines and Data Bus (D0-7) when an I/O operation occurs. Optionally putting the processor into a wait state until a continue button is pressed.

## KiCad design Diagostics Card.kicad_pcb

Parts:
C1, C2, C3, C4, C6: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C5: 10uF; CP_Radial_D5.0mm_P2.50mm
D1: N1; LED_D3.0mm
D2: N2; LED_D3.0mm
D3: N3; LED_D3.0mm
D4: N4; LED_D3.0mm
D5: N5; LED_D3.0mm
D6: N6; LED_D3.0mm
D7: N7; LED_D3.0mm
D8: IN; LED_D3.0mm
D9: OUT; LED_D3.0mm
D10: Q; LED_D3.0mm
D11: Data0; LED_D3.0mm
D12: Data1; LED_D3.0mm
D13: Data2; LED_D3.0mm
D14: Data3; LED_D3.0mm
D15: Data4; LED_D3.0mm
D16: Data5; LED_D3.0mm
D17: Data6; LED_D3.0mm
D18: Data7; LED_D3.0mm
D19: WAIT; LED_D3.0mm
H1, H2: Mounting Hole; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
JP1: Wait; PinHeader_1x02_P2.54mm_Horizontal
JP3: Run; PinHeader_1x02_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R21: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R20: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DIP_x01; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W7.62mm_P2.54mm_LowProfile
SW2: Run; SW_PUSH_6mm
U1: 74LS00; DIP-14_W7.62mm
U2: 74LS534; DIP-20_W7.62mm
U3: GAL22V10B; DIP-24_W7.62mm_Socket
U4: 74LS14; DIP-14_W7.62mm

Connections:
D0: J1.24, U2.3
D1: J1.23, U2.4
D2: J1.22, U2.7
D3: J1.21, U2.8
D4: J1.20, U2.13
D5: J1.19, U2.14
D6: J1.18, U2.17
D7: J1.17, U2.18
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, H1.1, H2.1, J1.39, J1.40, JP3.2, SW2.2, U1.7 (GND), U2.1, U2.10, U3.12, U4.7 (GND)
unnamed: C1.1, R19.2, R20.2, U4.9
unnamed: D1.1 (K), U3.22
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), U3.21
unnamed: D2.2 (A), R2.1
unnamed: D3.1 (K), U3.20
unnamed: D3.2 (A), R3.1
unnamed: D4.1 (K), U3.19
unnamed: D4.2 (A), R4.1
unnamed: D5.1 (K), U3.18
unnamed: D5.2 (A), R5.1
unnamed: D6.1 (K), U3.17
unnamed: D6.2 (A), R6.1
unnamed: D7.1 (K), U3.16
unnamed: D7.2 (A), R7.1
unnamed: D8.1 (K), U1.1, U1.2, U3.15
unnamed: D8.2 (A), R8.1
unnamed: D9.1 (K), U1.3
unnamed: D9.2 (A), R9.1
unnamed: D10.1 (K), U3.14
unnamed: D10.2 (A), R10.1
unnamed: D11.1 (K), U2.2
unnamed: D11.2 (A), R11.2
unnamed: D12.1 (K), U2.5
unnamed: D12.2 (A), R12.2
unnamed: D13.1 (K), U2.6
unnamed: D13.2 (A), R13.2
unnamed: D14.1 (K), U2.9
unnamed: D14.2 (A), R14.2
unnamed: D15.1 (K), U2.12
unnamed: D15.2 (A), R15.2
unnamed: D16.1 (K), U2.15
unnamed: D16.2 (A), R16.2
unnamed: D17.1 (K), U2.16
unnamed: D17.2 (A), R17.2
unnamed: D18.1 (K), U2.19
unnamed: D18.2 (A), R18.2
unnamed: D19.1 (K), U4.10
unnamed: D19.2 (A), R21.2
unnamed: JP1.2, SW1.2, U1.10, U1.11
unnamed: JP3.1, R20.1, SW2.1
unnamed: U1.4, U4.1, U4.8
unnamed: U1.5, U4.6
unnamed: U1.9, U3.1, U3.23, U4.13
unnamed: U1.8, U1.12, U4.11
unnamed: U1.6, U1.13
unnamed: U2.11, U4.12
unnamed: U4.2, U4.3
unnamed: U4.4, U4.5
Q: J1.7, U3.13
TPB: J1.16, U3.11
VCC: C2.1, C3.1, C4.1, C5.1, C6.1, J1.1, J1.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R21.1, U1.14 (VCC), U2.20, U3.24, U4.14 (VCC)
~IOR: J1.26, U3.9
~IOW: J1.25, U3.10
~N1: J1.33, U3.2
~N2: J1.32, U3.3
~N3: J1.31, U3.4
~N4: J1.30, U3.5
~N5: J1.29, U3.6
~N6: J1.28, U3.7
~N7: J1.27, U3.8
~WAIT: J1.3, JP1.1, SW1.1

Board: 2 copper layers, 100.0 x 100.0 mm, 57 parts (0 on the bottom side), 71 nets.

## Commit log

2021-11-06 Rev1.0
2021-11-06 Added README.md
2021-11-13 Corrected footprint and traces on Run button
2021-11-13 Add docs from github wiki
